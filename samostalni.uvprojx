# Keil uVision project samostalni.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F429ZITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: samostalni
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F429_439xx, USE_STDPERIPH_DRIVER, HSE_VALUE=8000000
  c include: ..\Projekt_Matija_Purgar;.\STM32F429I-Discovery;.\Lib\CMSIS\Include;.\Lib\CMSIS\Device\ST\STM32F4xx\Include;.\Lib\STM32F4xx_StdPeriph_Driver\inc;.\Include
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Header
    ./Include/: main.h timer.h gpio.h mjerenje.h
  group Source
    ./Source/: main.c timer.c gpio.c mjerenje.c
  group BSP
    ./Lib/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
    ./Lib/CMSIS/Device/ST/STM32F4xx/Include/: system_stm32f4xx.h
    ./Lib/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f429_439xx.s
    ./STM32F429I-Discovery/: stm32f429i_discovery.c stm32f429i_discovery.h stm32f429i_discovery_lcd.c stm32f429i_discovery_lcd.h stm32f429i_discovery_sdram.c stm32f429i_discovery_sdram.h
    ./Include/: stm32f4xx_it.h stm32f4xx_conf.h
    ./Source/: stm32f4xx_it.c stm32f4xx_fmc.c
  group STM_Lib
    ./: samostalni.lib
software components: CMSIS:CORE 5.2.0
